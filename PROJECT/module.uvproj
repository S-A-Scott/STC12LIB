# Keil uVision project module.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: module +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC;..\SRC
  group MAIN
    ../MAIN/: STARTUP.A51 main.c
  group INC
    ../INC/: timeout.h port.h main.h lcd12864.h hc_sr04.h pwm.h uart.h adc.h tm1650.h
  group SRC
    ../SRC/: lcd12864.c hc_sr04.c pwm.c uart.c adc.c timeout.c tm1650.c
